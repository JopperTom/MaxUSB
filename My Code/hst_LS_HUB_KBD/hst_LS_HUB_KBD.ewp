# IAR project hst_LS_HUB_KBD.ewp, settings and files
configuration Debug (MAXQ, debug)
  XLINK.XclFile: lnk0t.xcl
configuration Release (MAXQ)
  as the first configuration, except:
