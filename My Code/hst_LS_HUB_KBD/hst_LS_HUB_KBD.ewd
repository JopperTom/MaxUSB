<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>1</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>MAXQ</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>C-SPY</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>CInput</name>
          <state>1</state>
        </option>
        <option>
          <name>MacUseFile</name>
          <state>0</state>
        </option>
        <option>
          <name>MacFile</name>
          <state></state>
        </option>
        <option>
          <name>DynDriver</name>
          <state>MAXQSIM</state>
        </option>
        <option>
          <name>DDFUseFile</name>
          <state>1</state>
        </option>
        <option>
          <name>DDFFile</name>
          <state>$TOOLKIT_DIR$\Config\maxq200x.ddf</state>
        </option>
        <option>
          <name>RunToEnable</name>
          <state>1</state>
        </option>
        <option>
          <name>RunToName</name>
          <state>main</state>
        </option>
        <option>
          <name>OCGenSlave</name>
          <state>1</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>MAXQEMU</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>EMUDriverDummy</name>
          <state>1</state>
        </option>
        <option>
          <name>OEmuExtraOptions</name>
          <state></state>
        </option>
        <option>
          <name>RomFile</name>
          <state></state>
        </option>
        <option>
          <name>EmuRingFrequency</name>
          <state></state>
        </option>
        <option>
          <name>EmuCrystalFrequency</name>
          <state></state>
        </option>
      </data>
    </settings>
    <settings>
      <name>MAXQJTAG</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>JTAGDriverDummy</name>
          <state>1</state>
        </option>
        <option>
          <name>OJtagExtraOptions</name>
          <state></state>
        </option>
        <option>
          <name>JtagComPort</name>
          <state></state>
        </option>
      </data>
    </settings>
    <settings>
      <name>MAXQSIM</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>SIMDriverDummy</name>
          <state>1</state>
        </option>
        <option>
          <name>RomFile</name>
          <state>$TOOLKIT_DIR$\Config\romq20.hex</state>
        </option>
        <option>
          <name>OCEnableRegBp</name>
          <state>0</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>MAXQ</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>C-SPY</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>CInput</name>
          <state>1</state>
        </option>
        <option>
          <name>MacUseFile</name>
          <state>0</state>
        </option>
        <option>
          <name>MacFile</name>
          <state></state>
        </option>
        <option>
          <name>DynDriver</name>
          <state>MAXQSIM</state>
        </option>
        <option>
          <name>DDFUseFile</name>
          <state>1</state>
        </option>
        <option>
          <name>DDFFile</name>
          <state>###Uninitialized###</state>
        </option>
        <option>
          <name>RunToEnable</name>
          <state>1</state>
        </option>
        <option>
          <name>RunToName</name>
          <state>main</state>
        </option>
        <option>
          <name>OCGenSlave</name>
          <state>1</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>MAXQEMU</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>EMUDriverDummy</name>
          <state>1</state>
        </option>
        <option>
          <name>OEmuExtraOptions</name>
          <state></state>
        </option>
        <option>
          <name>RomFile</name>
          <state></state>
        </option>
        <option>
          <name>EmuRingFrequency</name>
          <state></state>
        </option>
        <option>
          <name>EmuCrystalFrequency</name>
          <state></state>
        </option>
      </data>
    </settings>
    <settings>
      <name>MAXQJTAG</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>JTAGDriverDummy</name>
          <state>1</state>
        </option>
        <option>
          <name>OJtagExtraOptions</name>
          <state></state>
        </option>
        <option>
          <name>JtagComPort</name>
          <state></state>
        </option>
      </data>
    </settings>
    <settings>
      <name>MAXQSIM</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>SIMDriverDummy</name>
          <state>1</state>
        </option>
        <option>
          <name>RomFile</name>
          <state>###Uninitialized###</state>
        </option>
        <option>
          <name>OCEnableRegBp</name>
          <state>0</state>
        </option>
      </data>
    </settings>
  </configuration>
</project>


